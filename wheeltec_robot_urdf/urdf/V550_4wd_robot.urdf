Commit message: Fix wheel joint axis direction in robot URDF

File: wheeltec_robot_urdf/urdf/V550_4wd_robot.urdf (robot description, URDF)
Before this commit: robot V550_4wd_robot, 8 links, 7 joints
Joints:
- joint lb_wheel_joint: axis 0 -1 0 -> 0 1 0
- joint lf_wheel_joint: axis 0 -1 0 -> 0 1 0
